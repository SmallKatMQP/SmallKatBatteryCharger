# Repository SmallKatMQP/SmallKatBatteryCharger

## KiCad design SmallKat Battery Charger.kicad_pcb

Parts:
C1, C7, C9, C10, C12: 0.1uF; C_0402_1005Metric
C2: 47nF; C_0402_1005Metric
C3, C8, C15, C16: 1uF; C_0402_1005Metric
C4, C5: 10uF; C_0805_2012Metric
C6: 200uF; C_0805_2012Metric
C11: 0.33uF; C_0402_1005Metric
D1, D2: D_Schottky_ALT; D_SOT-23_ANK
D3, D4, D5: LED; LED_0603_1608Metric
J1, J6, J7: Conn_01x02_Male; Molex_CLIK-Mate_502443-0270_1x02-1MP_P2.00mm_Vertical
J2: Conn_01x04_Male; 1x4Pads
J3: Conn_01x04_Male; Molex_CLIK-Mate_502443-0470_1x04-1MP_P2.00mm_Vertical
J4: Conn_01x03_Male; Molex_CLIK-Mate_502494-0370_1x03-1MP_P2.00mm_Horizontal
J5: Conn_01x06_Male; Molex_CLIK-Mate_502494-0670_1x06-1MP_P2.00mm_Horizontal
L1: 2.2uH; L_12x12mm_H6mm
Q1, Q2: BUK7M33-60EX; VSON-8_3.3x3.3mm_P0.65mm_NexFET
Q4: DMP3013SFV; VSON-8_3.3x3.3mm_P0.65mm_NexFET
R1, R5, R8, R10, R14, R19: 10k; R_0402_1005Metric
R2: 430k; R_0402_1005Metric
R3: 66.5k; R_0402_1005Metric
R4, R6: 4k; R_0402_1005Metric
R7, R16: 10m; R_1206_3216Metric
R9: 15; R_0402_1005Metric
R11: 160; R_0805_2012Metric
R12: 260; R_0805_2012Metric
R13: 100k; R_0402_1005Metric
R15: 6.5k; R_0402_1005Metric
R17: 100; R_0805_2012Metric
R18: 100; R_0402_1005Metric
R20: 10; R_1206_3216Metric
R25, R26, R27: 330; R_0402_1005Metric
U1: CSD87312Q3E
U2: STM32L432KBUx; QFN-32-1EP_5x5mm_P0.5mm_EP3.45x3.45mm
U3: BQ24715
U4: BQ29200
U6: MIC5504-3.3YM5; SOT-23-5

Connections:
+3V3: C16.2, J2.1, J3.1, R5.1, R8.2, R10.1, U2.1 (VDD), U2.5 (VDDA), U2.17 (VDD), U6.5 (VOUT)
+BATT: C8.2, C15.2, J5.1, J6.1, J7.1, Q4.5 (D), R14.1, R18.1, U6.1 (VIN), U6.3 (EN)
ACDET: R2.2, R3.1, U3.6
ACN: C4.1, Q1.5 (D), R7.1, U3.1
ACOK: R5.2, U2.10 (PA4), U3.5
ACP: R7.2, U1.8 (D2), U3.2
ADAPTER: J1.2, R2.1, R20.1, U1.1 (D1)
ALERT: R19.1, U2.8 (PA2)
BATDRV: Q4.4 (G), U3.11
BATTVOLTAGE: R14.2, R15.1, U2.9 (PA3)
BTST: C2.1, D2.1 (K), R9.1
CELL1_IN: J4.2, R12.2, R17.2
CELL2_IN: J4.3, R11.2
CS: J5.6, U2.14 (PB0)
GATE: C1.1, R4.2, U1.5 (GATE)
GND: C3.1, C4.2, C5.2, C6.1, C8.1, C10.2, C11.2, C12.2, C15.1, C16.1, D3.1 (K), D4.1 (K), D5.1 (K), J1.1, J2.2, J3.2, J4.1, J5.2, J6.2, J7.2, Q2.1 (S), Q2.2 (S), Q2.3 (S), R1.2, R3.2, R15.2, U2.16 (VSS), U2.32 (VSS), U2.33 (VSS), U3.14, U3.21, U4.5 (GND), U4.6 (CB_EN), U4.9 (EPAD), U6.2 (GND)
HIDRV: Q1.4 (G), U3.18
IOUT: U2.7 (PA1), U3.7
LED1: R25.2, U2.3 (PC15)
LED2: R26.2, U2.6 (PA0)
LED3: R27.2, U2.2 (PC14)
LODRV: Q2.4 (G), U3.15
MISO: J5.4, U2.12 (PA6)
MOSI: J5.5, U2.13 (PA7)
unnamed: C9.1, R11.1, U4.1 (VC2)
unnamed: C9.2, C10.1, R12.1, U4.2 (VC1)
unnamed: C11.1, U4.4 (CD)
unnamed: C12.1, R18.2, U4.7 (VDD)
unnamed: D1.1 (K), U3.20
unnamed: D1.2 (A), R20.2
unnamed: D3.2 (A), R25.1
unnamed: D4.2 (A), R26.1
unnamed: D5.2 (A), R27.1
unnamed: R1.1, U2.31 (PH3)
unnamed: R4.1, U3.4
unnamed: R6.1, U3.3
unnamed: R9.2, U3.17
unnamed: R13.2, U3.10
unnamed: R17.1, U4.3 (VC1_CB)
OUT: R19.2, U4.8 (OUT)
PHASE: C2.2, L1.1, Q1.1 (S), Q1.2 (S), Q1.3 (S), Q2.5 (D), U3.19
REGN: C3.2, D2.2 (A), R13.1, U3.16
RX: J3.4, U2.30 (PB7)
SCK: J5.3, U2.11 (PA5)
SCL: R10.2, U2.19 (PA9), U3.9
SDA: R8.1, U2.20 (PA10), U3.8
SOURCE: C1.2, R6.2, U1.9 (SOURCE)
SRN: C7.1, Q4.1 (S), Q4.2 (S), Q4.3 (S), R16.1, U3.12
SRP: C5.1, C6.2, C7.2, L1.2, R16.2, U3.13
SWCLK: J2.4, U2.24 (PA14)
SWDIO: J2.3, U2.23 (PA13)
TX: J3.3, U2.29 (PB6)

Notes on the sheet:
Power In
Batt Out
Programming
Serial
Balance
SPI
LEDs
Voltage Divider
Micro Controller
3.3v regulator
Balace Circuit
ACOK Pullup
Input current sense resistor
Charger output

Board: 4 copper layers, 50.0 x 50.0 mm, 58 parts (16 on the bottom side), 52 nets.

## Commit log

2018-12-19 upated board layout
2018-12-19 updated footprints
2018-12-19 updated gerber
